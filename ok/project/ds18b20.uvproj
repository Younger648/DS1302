# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sourse
  asm include: ..\sourse
  group main
    ../sourse/: main.c
  group c
    ../sourse/: iic.c onewire.c head.c hc138.c SMG.c Timer.c ds18b20.c ds1302.c ds1302g.c
  group h
    ../sourse/: iic.h onewire.h head.h Timer.h ds18b20.h ds1302.h ds1302g.h config.h hc138.h
